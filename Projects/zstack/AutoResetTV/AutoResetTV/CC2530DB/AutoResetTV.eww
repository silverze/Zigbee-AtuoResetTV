<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\AutoResetTV.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>AutoResetTV</project>
        <configuration>DemoEB</configuration>
      </member>
      <member>
        <project>AutoResetTV</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>AutoResetTV</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>AutoResetTV</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


